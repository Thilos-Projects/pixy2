# Keil uVision project libpixy_m0.uvproj, settings and files
target libpixy_m0 (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: libpixy_m0 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CORE_M0  IPC_SLAVE PIXY KEIL
  c include: ., ..\..\common\inc, ..\common\inc, inc
  asm define: NO_CRP  IPC_SLAVE
  library: MicroLIB
  group Source Code
    ./src/: chirp.c debug.c exec_m0.c frame_m0.c rls_m0.c smlink.c qqueue.c
    ../common/src/: debug_frmwrk.c ipc_mbx.c lpc43xx_uart.c
